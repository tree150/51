# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: menu.c menu.h main.c PWM.c PWM.h UART.c UART.h Timer.c Timer.h
    ../10-2 DS1302可调时钟/: Key.c Key.h
    ../14-1 LCD1602液晶显示屏/: Delay.c Delay.h
    ../5-2 lcd调试工具/: LCD1602.c LCD1602.h
